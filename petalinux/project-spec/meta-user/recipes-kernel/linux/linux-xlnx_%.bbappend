SRC_URI_append = " file://0001-disable-axienet-mdio.patch"
  
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

